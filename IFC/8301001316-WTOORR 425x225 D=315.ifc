Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 3c9c1052-0aff-42b0-a390-62310f3d93d0, NumberOfSaves: 27]
File name: 8301001316-WTOORR 425x225 D=315.ifc
Time: 2024-12-02T10:43:43+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENU) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingElementProxy: NLRS_57_DUA_UN_plenum_for_supply_wall_grill_wto_LT_Solid_Air:WTOO, NLRS_57_DUA_UN_plenum_for_supply_wall_grill_wto_LT_Solid_Air:WTOO:1606053
In: Default
Type - Material: SACS_Label, NLRS_57_sendzimir verzinkt_gen_sacs
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_plenum_for_supply_wall_grill_wto_LT_Solid_Air
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: 57.00; Description: WTO, plenum for wall grill; Manufacturer: Solid Air Climate Solutions; Model: WTO, plenum for wall grill; NLRS_C_content_creator: J.Feeke; NLRS_C_content_datum_gewijzigd: 02-12-2024; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.21.01; NLRS_C_description: WTO, plenum for wall grill; Type Name: WTOO; URL: https://solid-air.nl/producten/wto-wro/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: WTOO; sets with these values: 2
Other - Family: NLRS_57_DUA_UN_plenum_for_supply_wall_grill_wto_LT_Solid_Air; Family and Type: NLRS_57_DUA_UN_plenum_for_supply_wall_grill_wto_LT_Solid_Air: WTOO; Type: WTOO; Type Id: 1605892
Model Properties - Connection side (0-2): 1; Plenum type (0-1): 1; SACS_Option_1: Right; SACS_Option_2: Insulated
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.812004 m2; NLRS_C_lengte: 490 mm; NLRS_M_c01_breedte: 425 mm; NLRS_M_c01_hoogte: 225 mm; NLRS_M_c02_diameter: 315 mm; SACS_Duct_Height: 225 mm; SACS_Duct_Width: 425 mm; Size: 425x225-315ø-315ø-315ø; Volume: 0.0771649 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 159; NLRS_C_model: WTOORR 425x225 D=315; SACS_Article_Code: 8301001316
Mechanical - System Classification: Supply Air
Mechanical - Flow - NLRS_M_c01_debiet: 0 dm3/s
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 425 mmx225 mm-315 mmø-315 mmø-315 mmø
Lining - Free Size: 425 mmx225 mm-315 mmø-315 mmø-315 mmø; Lining Thickness: 0 mm

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection
OutPort_1606053_1 | SOURCE
InPort_1606053_2 | SINK
InPort_1606053_3 | SINK
InPort_1606053_4 | SINK
